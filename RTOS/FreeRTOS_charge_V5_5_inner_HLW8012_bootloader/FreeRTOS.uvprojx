# Keil uVision project FreeRTOS.uvprojx, settings and files
target SWM320 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.2.0.4
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: FreeRTOS +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: MBEDTLS_CONFIG_FILE=<config-mini-tls1_1.h>
  c include: ..\..\SWM320_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM320_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM320_StdPeriph_Driver\CSL\SWM320_StdPeriph_Driver;.\APP;.\APP\FreeRTOS\include;.\APP\FreeRTOS\portable\RVDS\ARM_CM3;.\APP\task;.\Framework;.\Framework\softpack\mbedtls\include;.\Framework\softpack\mbedtls\config;.\APP\work;.\APP\hw_action
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: list.c queue.c tasks.c timers.c croutine.c
  group FreeRTOS\port
    ./APP/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./APP/FreeRTOS/portable/MemMang/: heap_4.c
  group CSL\StdPD
    ../../SWM320_StdPeriph_Driver/CSL/SWM320_StdPeriph_Driver/: SWM320_adc.c SWM320_exti.c SWM320_gpio.c SWM320_i2c.c SWM320_pwm.c SWM320_timr.c SWM320_uart.c SWM320_wdt.c SWM320_dma.c SWM320_flash.c SWM320_port.c SWM320_spi.c SWM320_can.c SWM320_crc.c SWM320_lcd.c SWM320_rtc.c SWM320_sdio.c
  group CSL\CMSIS
    ../../SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM320.c
    ../../SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM320.s
  group task
    ./APP/task/task_start/: task_start.c
    ./APP/: test_mbedtls.c
    ./APP/task/task_listen/: task_listen.c
    ./APP/task/task_ctrl/: task_ctrl.c
    ./APP/task/task_host/: task_host.c
  group fk/drivers
    ./Framework/drivers/: fk_drv_uart0.c fk_drv_uart1.c fk_drv_uart_loop.c fk_drv_hc595_bus.c fk_drv_gpio.c
  group fk/drv_port
    ./Framework/drivers/driver_port/: fk_drv_port_pwm.c fk_drv_port_uart0.c fk_drv_port_uart1.c fk_drv_port_gpio.c
  group fk/byte_arary
    ./Framework/softpack/byte_array/: byte_array.c
  group fk/sysprt
    ./Framework/softpack/sysprt/: sysprt.c sysprt_cmd_base.c sysprt_cmd_man.c sysprt_cmd_util.c
  group fk/mbedtls/libraries
    ./Framework/softpack/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md2.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c md.c md5.c
  group fk/mbedtls/config
    ./Framework/softpack/mbedtls/config/: config-mini-tls1_1.h
  group fk/strlib
    ./Framework/softpack/strlib/: strlib.c strlib_url.c
  group fk/air_man
    ./Framework/softpack/air_man/: air_man.c air_man_inc_conf.h air_man_typedef.h
  group work/work_cpn/air724
    ./APP/work/work_cpn/air724/: air724_innner.h air724.c air724_aoto_baudrate.c air724_cmd_AT.c air724_cmd_AT_CGMI.c air724_cmd_AT_CGMR.c air724_cmd_AT_CPIN.c air724_cmd_AT_CSQ.c air724_cmd_AT_CREG.c air724_cmd_AT_CGATT.c air724_cmd_AT_CSTT.c air724_cmd_AT_CIICR.c air724_cmd_AT_CIFSR.c air724_cmd_AT_CIPMODE.c air724_cmd_AT_CIPSTART.c air724_cmd_AT_CIPCLOSE.c air724_cmd_AT_CIPMUX.c air724_http_date_get.c air724_cmd_AT_RESET.c
  group work
    ./APP/work/: work.c work_data.c work_debug.c
  group work/internet
    ./APP/work/: work_internet_init_hardware.c work_internet_work_env.c work_internet_create_and_rst.c work_internet.c work_internet_http.c work_internet_http_download.c
  group work/work_cpn/led_board
    ./APP/work/work_cpn/led_board/: led_board.c led_board_inc_conf.h led_board_typedef.h
  group fk/font
    ./Framework/softpack/font/: font_ascii_16.c
  group fk/dot_ui
    ./Framework/softpack/dot_ui/: dot_ui_api.c dot_ui_inc_conf.h dot_ui_typedef.h
  group fk/xmodem
    ./Framework/softpack/xmodem/: xmodem.c xmodem.h
