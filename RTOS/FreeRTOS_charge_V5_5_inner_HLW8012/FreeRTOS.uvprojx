# Keil uVision project FreeRTOS.uvprojx, settings and files
target SWM320 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.2.0.4
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: FreeRTOS +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: .\build_ota_file.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: MBEDTLS_CONFIG_FILE=<config-mini-tls1_1.h>
  c include: ..\..\SWM320_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM320_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM320_StdPeriph_Driver\CSL\SWM320_StdPeriph_Driver;.\APP;.\APP\FreeRTOS\include;.\APP\FreeRTOS\portable\RVDS\ARM_CM3;.\APP\task;.\Framework;.\Framework\softpack\mbedtls\include;.\Framework\softpack\mbedtls\config;.\APP\work;.\APP\hw_action;.\Framework\softpack\FlashDB\inc;.\Framework\softpack\FlashDB\port\fal\inc;.\Framework\softpack\FlashDB\port\FlashDB_port;.\Framework\softpack\FlashDB\port\fal_port
  library: MicroLIB
  memory RVCT4: ROM 0x50000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: list.c queue.c tasks.c timers.c croutine.c
  group FreeRTOS\port
    ./APP/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./APP/FreeRTOS/portable/MemMang/: heap_4.c
  group CSL\StdPD
    ../../SWM320_StdPeriph_Driver/CSL/SWM320_StdPeriph_Driver/: SWM320_adc.c SWM320_exti.c SWM320_gpio.c SWM320_i2c.c SWM320_pwm.c SWM320_timr.c SWM320_uart.c SWM320_wdt.c SWM320_dma.c SWM320_flash.c SWM320_port.c SWM320_spi.c SWM320_can.c SWM320_crc.c SWM320_lcd.c SWM320_rtc.c SWM320_sdio.c
  group CSL\CMSIS
    ../../SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM320.c
    ../../SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM320.s
  group task
    ./APP/task/task_start/: task_start.c
    ./APP/: test_mbedtls.c
    ./APP/task/task_listen/: task_listen.c
    ./APP/task/task_ctrl/: task_ctrl.c
    ./APP/task/task_host/: task_host.c
  group fk/drivers
    ./Framework/drivers/: fk_drv_uart0.c fk_drv_uart1.c fk_drv_uart2.c fk_drv_uart3.c fk_drv_uart_loop.c fk_drv_hc595_bus.c fk_drv_gpio.c fk_drv_rtc.c fk_drv_coder.c
  group fk/drv_port
    ./Framework/drivers/driver_port/: fk_drv_port_uart0.c fk_drv_port_uart1.c fk_drv_port_uart2.c fk_drv_port_uart3.c fk_drv_port_tim0.c fk_drv_port_gpio.c fk_drv_port_rtc.c fk_drv_port_cntr.c
  group fk/byte_arary
    ./Framework/softpack/byte_array/: byte_array.c
  group fk/sysprt
    ./Framework/softpack/sysprt/: sysprt.c sysprt_cmd_base.c sysprt_cmd_man.c sysprt_cmd_util.c
  group fk/mbedtls/libraries
    ./Framework/softpack/mbedtls/library/: aesni.c aes.c base64.c arc4.c aria.c asn1parse.c asn1write.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md2.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c md.c md5.c
  group fk/mbedtls/config
    ./Framework/softpack/mbedtls/config/: config-mini-tls1_1.h
  group fk/strlib
    ./Framework/softpack/strlib/: strlib.c strlib_url.c
  group fk/air_man
    ./Framework/softpack/air_man/: air_man.c air_man_inc_conf.h air_man_typedef.h
  group work/work_cpn/air724
    ./APP/work/work_cpn/air724/: air724_innner.h air724.c air724_aoto_baudrate.c air724_cmd_AT.c air724_cmd_AT_CGMI.c air724_cmd_AT_CGMR.c air724_cmd_AT_CPIN.c air724_cmd_AT_CSQ.c air724_cmd_AT_CREG.c air724_cmd_AT_CGATT.c air724_cmd_AT_CSTT.c air724_cmd_AT_CIICR.c air724_cmd_AT_CIFSR.c air724_cmd_AT_CIPMODE.c air724_cmd_AT_CIPSTART.c air724_cmd_AT_CIPCLOSE.c air724_cmd_AT_CIPMUX.c air724_http_date_get.c air724_cmd_AT_RESET.c
  group work
    ./APP/work/: work.c work_data.c work_debug.c work_restart_order.c work_data_new.c work_flashDB.c work_time_base.c
  group work/internet/wira
    ./APP/work/wira/: wira.c wira_nwdt.c wira_wrok_cycle.c wira_deal_cmd_from_server.c wira_event_report.c wira_interactive_pool.c
  group work/internet
    ./APP/work/: work_internet_recv_analysis.c work_internet_connect_server.c work_internet_aes_base64.c work_internet_http_date.c work_internet_init_hardware.c work_internet_work_env.c work_internet_create_and_rst.c work_internet.c
  group work/work_cpn/sock
    ./APP/work/work_cpn/sock/: sock.c sock_mq.c sock_ctrl.c sock_inc_conf.h sock_typedef.h sock_fuse.c sock_deal_order.c sock_charg_timer.c sock_hlw8012.c
  group work/work_cpn/led_board
    ./APP/work/work_cpn/led_board/: led_board.c led_board_inc_conf.h led_board_typedef.h
  group fk/dot_ui
    ./Framework/softpack/dot_ui/: dot_ui_api.c dot_ui_inc_conf.h dot_ui_typedef.h
  group fk/font
    ./Framework/softpack/font/: font_ascii_16.c font_ascii_inc_conf.h
  group fk/flashDB
    ./Framework/softpack/FlashDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group fk/flashDB/sample
    ./Framework/softpack/FlashDB/samples/: kvdb_basic_sample.c kvdb_type_blob_sample.c kvdb_type_string_sample.c tsdb_sample.c
  group fk/flashDB/port
    ./Framework/softpack/FlashDB/port/FlashDB_port/: fdb_cfg.h
  group fk/fal
    ./Framework/softpack/FlashDB/port/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group fk/fal/port
    ./Framework/softpack/FlashDB/port/fal_port/: fal_flash_swm341.c fal_cfg.h
